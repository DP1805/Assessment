Commit message: chaged camera orientation for better view in gazebo

File: robot_17/urdf/robot_17.urdf (robot description, URDF)
Before this commit: robot robot_17, 7 links, 6 joints
Links:
- link C_Link: geometry collision box size=0.01 0.01 0.15; visual box size=0.01 0.01 0.15
